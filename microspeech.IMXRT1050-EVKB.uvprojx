# Keil uVision project microspeech.IMXRT1050-EVKB.uvprojx, settings and files
target IMXRT1050-EVKB (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.13.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: microspeech
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: CODEC_WM8960_ENABLE SKIP_SYSCLK_INIT XIP_BOOT_HEADER_DCD_ENABLE=1 XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-missing-noreturn -Wno-missing-prototypes -Wno-missing-variable-declarations -Wno-nonportable-include-path -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -fno-exceptions -gdwarf-4 -xc++
  c include: .;.\VSI\audio\include;.\micro_speech\src
  asm define: as above
  asm include: .;./VSI/audio/include;./micro_speech/src
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ./RTE/Device/MIMXRT1052DVL6B/MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group App
    ./: microspeech.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group Driver
    ./Driver_Audio/: Audio_IMXRT1050-EVKB.c
  group MCUXpresso
    ./: IMXRT1050-EVKB.mex
  group Documentation
    ./: README.md
  group TF_micro_frontend
    ./micro_speech/src/microfrontend/lib/: fft.cc fft_util.cc filterbank.c filterbank_util.c frontend.c frontend_util.c log_lut.c log_scale.c log_scale_util.c noise_reduction.c noise_reduction_util.c pcan_gain_control.c pcan_gain_control_util.c window.c window_util.c
  group TF_micro_features
    ./micro_speech/src/micro_features/: micro_features_generator.cc micro_model_settings.cc model.cc no_micro_features_data.cc yes_micro_features_data.cc
  group TF_main
    ./micro_speech/src/: audio_provider.cc command_responder.cc feature_provider.cc main_functions.cc recognize_commands.cc
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:NN Lib 3.0.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 1.2.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.3.0, CMSIS Driver:VIO:Board 1.0.1, Board Support:SDK Drivers:evkbimxrt1050 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.2.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:codec 2.2.2, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.3.0, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.2, Device:SDK Drivers:enet 2.5.0, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:i2c 2.3.0, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.5.1, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.5.0, Device:SDK Drivers:nic301 2.0.0, Device:SDK Drivers:sai 2.3.3, Device:SDK Drivers:sai_edma 2.4.0, Device:SDK Drivers:sdhc 2.8.0, Device:SDK Drivers:wm8960 2.2.0, Device:SDK Drivers:wm8960_adapter 2.2.0, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.4.0, Machine Learning:TensorFlow:Kernel 0.4.0
